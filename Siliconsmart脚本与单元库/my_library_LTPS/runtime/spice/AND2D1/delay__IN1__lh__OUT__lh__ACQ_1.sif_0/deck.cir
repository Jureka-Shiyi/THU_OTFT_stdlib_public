.title delay__IN1__lh__OUT__lh__ACQ_1

* state: IN2
* state_coverage: IN2

* Deck file generated by SiliconSmart T-2022.03-SP2-1 build date: Jun 27, 2022 10:33:00. (SMSC-2)
* SiliconSmart path: /tools/Synopsys/siliconsmart/T-2022.03-SP2-1/linux64/bin/siliconsmart
* Host Name: cad52, User Name: , PID: 58846
* Directory: /var/tmp/siliconsmart.cad52.1040.58846/AND2D1/delay__IN1__lh__OUT__lh__ACQ_1.sif_0

* Circuit simulation deck copyright (c) 1998-Present
* Synopsys Inc.  This file contains proprietary
* and confidential information.  All rights reserved.

* **************************
* Process Corner
* **************************

.lib "/data/tangwj/Cadence/TIANMA_LTPS2021/PDK_TIANMA_LTPS2021/tianma_ltps_2021.l" ntft_mac
.lib "/data/tangwj/Cadence/TIANMA_LTPS2021/PDK_TIANMA_LTPS2021/tianma_ltps_2021.l" ptft_mac

* **************************
* Temperature
* **************************

.temp 25

* **************************
* Options
* **************************

.option post=0
.option probe=1
.option numdgt=10 measdgt=10 autostop=1
.option ingold=1 lennam=16 nomod=1 brief=1 lislvl=1 statfl=1 warnlimit=5 pivot=0 symb=1 post_version=9601
.option measform=1
.option cell_char=yes
.option  probe=1 runlvl=5 numdgt=7 measdgt=7 acct=1 nopage
.option measout=1 putmeas=0

.save TYPE=ic LEVEL=NONE
* **************************
* Parameters
* **************************

.param __param_in2 = 10
.param __param_vdd = 10
.param __param_vss = 0
.param ct = 2.7e-07
.param default_slew = 1.5e-11
.param energy_change_abs_threshold = 1.5e-11
.param energy_change_threshold = 0.15
.param initial_delay = 1e-11
.param load_out = 1e-14
.param pp = 1.32e-07
.param slew_in1 = 1e-10
.param temperature_tag = 25
.param units = 2.7e-07
.param end_time = 3.999700999999999e-07
.data arc_data
+ slew_in1 load_out temperature_tag __param_vdd __param_vss
+ 1e-10 1e-14 25 10 0
+ 1e-10 8e-14 25 10 0
+ 1e-10 1.5e-13 25 10 0
+ 1e-10 2e-13 25 10 0
+ 1e-10 2.8e-13 25 10 0
+ 1e-10 3.5e-13 25 10 0
+ 1e-10 4.5e-13 25 10 0
+ 2e-10 1e-14 25 10 0
+ 2e-10 8e-14 25 10 0
+ 2e-10 1.5e-13 25 10 0
+ 2e-10 2e-13 25 10 0
+ 2e-10 2.8e-13 25 10 0
+ 2e-10 3.5e-13 25 10 0
+ 2e-10 4.5e-13 25 10 0
+ 3e-10 1e-14 25 10 0
+ 3e-10 8e-14 25 10 0
+ 3e-10 1.5e-13 25 10 0
+ 3e-10 2e-13 25 10 0
+ 3e-10 2.8e-13 25 10 0
+ 3e-10 3.5e-13 25 10 0
+ 3e-10 4.5e-13 25 10 0
+ 4e-10 1e-14 25 10 0
+ 4e-10 8e-14 25 10 0
+ 4e-10 1.5e-13 25 10 0
+ 4e-10 2e-13 25 10 0
+ 4e-10 2.8e-13 25 10 0
+ 4e-10 3.5e-13 25 10 0
+ 4e-10 4.5e-13 25 10 0
+ 5e-10 1e-14 25 10 0
+ 5e-10 8e-14 25 10 0
+ 5e-10 1.5e-13 25 10 0
+ 5e-10 2e-13 25 10 0
+ 5e-10 2.8e-13 25 10 0
+ 5e-10 3.5e-13 25 10 0
+ 5e-10 4.5e-13 25 10 0
+ 7e-10 1e-14 25 10 0
+ 7e-10 8e-14 25 10 0
+ 7e-10 1.5e-13 25 10 0
+ 7e-10 2e-13 25 10 0
+ 7e-10 2.8e-13 25 10 0
+ 7e-10 3.5e-13 25 10 0
+ 7e-10 4.5e-13 25 10 0
+ 1e-09 1e-14 25 10 0
+ 1e-09 8e-14 25 10 0
+ 1e-09 1.5e-13 25 10 0
+ 1e-09 2e-13 25 10 0
+ 1e-09 2.8e-13 25 10 0
+ 1e-09 3.5e-13 25 10 0
+ 1e-09 4.5e-13 25 10 0
.enddata

* **************************
* Global nodes
* **************************

* **************************
* Network
* **************************

.inc '/data/zhengyj/OTFT_stdlib/my_library_LTPS/netlists/AND2D1.cdl'
xand2d1_inst in1 in2 vss vdd out AND2D1
vin1_meter in1 in1_harness dc 0
vin2_meter in2 in2_harness dc 0
vin2_stim in2_harness 0 dc 10
vout_meter out out_harness dc 0
vvdd_meter vdd vdd_harness dc 0
vvdd_stim vdd_harness 0 dc 10
cvdd_stim_cap vdd_harness 0 1e-15
vvss_meter vss vss_harness dc 0
vvss_stim vss_harness 0 dc 0
cvss_stim_cap vss_harness 0 1e-15
ccap_out out_harness ground_out 'load_out'
vcap_ground_out ground_out 0 dc 0
vin1_stim in1_harness 0 pwl
+  0  0
+  1e-11  0
+  '1e-11 + slew_in1 * 2.5'  10
+  1.3201e-07  10
* **************************
* Measurements
* **************************

.meas tran cin__in1__lh_trig when v(in1)=0.5 cross=1 td=1e-11
.meas tran cin__in1__lh_targ when v(in1)=9.5 cross=1 td=1e-11
.meas tran cin__in1__lh_q integ i(vin1_meter) from='cin__in1__lh_trig' to='cin__in1__lh_targ'
* Return abs((Cin__IN1__lh_q)/(9))
.meas tran tin__in1__lh_trig when v(in1)=3 rise=1 td=1e-11
.meas tran tin__in1__lh_targ when v(in1)=7 rise=1 td=1e-11
* Return ((Tin__IN1__lh_targ)-(Tin__IN1__lh_trig))*(1)
.meas tran tout__out__lh_trig when v(out)=3 rise=1 td=1e-11
.meas tran tout__out__lh_targ when v(out)=7 rise=1 td=1e-11
* Return ((Tout__OUT__lh_targ)-(Tout__OUT__lh_trig))*(1)
.meas tran cap_energy__out__lh_vp0 find v(out_harness) at=1e-11
.meas tran cap_energy__out__lh_vp1 find v(out_harness) at=1.3201e-07
.meas tran cap_energy__out__lh_vn0 find v(ground_out) at=1e-11
.meas tran cap_energy__out__lh_vn1 find v(ground_out) at=1.3201e-07
* Return (((0.5)*(cap_OUT.value))*(cap_energy__OUT__lh_vp1-cap_energy__OUT__lh_vn1-cap_energy__OUT__lh_vp0+cap_energy__OUT__lh_vn0))*(cap_energy__OUT__lh_vp1-cap_energy__OUT__lh_vn1-cap_energy__OUT__lh_vp0+cap_energy__OUT__lh_vn0)
.meas tran delay__in1__lh__out__lh_trig when v(in1)=5 rise=1 td=1e-11
.meas tran delay__in1__lh__out__lh_targ when v(out)=5 rise=1 td=1e-11
* Return ((delay__IN1__lh__OUT__lh_targ)-(delay__IN1__lh__OUT__lh_trig))*(1)
.meas tran energy1__in1__lh__out__lh__vdd_vdd_harness_v find v(vdd_harness) at=1.3201e-07
.meas tran energy1__in1__lh__out__lh__vdd_vdd_harness_q integ i(vvdd_stim) from=1e-11 to=1.3201e-07
* Return (0)-((energy1__IN1__lh__OUT__lh__VDD_VDD_harness_v)*(energy1__IN1__lh__OUT__lh__VDD_VDD_harness_q))
.meas tran energy1__in1__lh__out__lh__vss_vss_harness_v find v(vss_harness) at=1.3201e-07
.meas tran energy1__in1__lh__out__lh__vss_vss_harness_q integ i(vvss_stim) from=1e-11 to=1.3201e-07
* Return (0)-((energy1__IN1__lh__OUT__lh__VSS_VSS_harness_v)*(energy1__IN1__lh__OUT__lh__VSS_VSS_harness_q))
.meas tran energy__in1__lh__out__lh_vdd_harness_v find v(vdd_harness) at=1.3201e-07
.meas tran energy__in1__lh__out__lh_vdd_harness_q integ i(vvdd_stim) from=1e-11 to=1.3201e-07
* Return (0)-((energy__IN1__lh__OUT__lh_VDD_harness_v)*(energy__IN1__lh__OUT__lh_VDD_harness_q))
.meas tran leakage_power1__vdd_vdd_harness_v avg v(vdd_harness) from=1.2541e-07 to=1.3201e-07
.meas tran leakage_power1__vdd_vdd_harness_i avg i(vvdd_stim) from=1.2541e-07 to=1.3201e-07
* Return (0)-((leakage_power1__VDD_VDD_harness_v)*(leakage_power1__VDD_VDD_harness_i))
.meas tran leakage_power1__vss_vss_harness_v avg v(vss_harness) from=1.2541e-07 to=1.3201e-07
.meas tran leakage_power1__vss_vss_harness_i avg i(vvss_stim) from=1.2541e-07 to=1.3201e-07
* Return (0)-((leakage_power1__VSS_VSS_harness_v)*(leakage_power1__VSS_VSS_harness_i))
.meas tran leakage_power2__vdd_vdd_harness_v avg v(vdd_harness) from=1.1881e-07 to=1.2541e-07
.meas tran leakage_power2__vdd_vdd_harness_i avg i(vvdd_stim) from=1.1881e-07 to=1.2541e-07
* Return (0)-((leakage_power2__VDD_VDD_harness_v)*(leakage_power2__VDD_VDD_harness_i))
.meas tran leakage_power2__vss_vss_harness_v avg v(vss_harness) from=1.1881e-07 to=1.2541e-07
.meas tran leakage_power2__vss_vss_harness_i avg i(vvss_stim) from=1.1881e-07 to=1.2541e-07
* Return (0)-((leakage_power2__VSS_VSS_harness_v)*(leakage_power2__VSS_VSS_harness_i))
* **************************
* Analysis
* **************************

* Analysis.tranPlus.
.tran 1e-10 3.999700999999999e-07 sweep data=arc_data

.end
